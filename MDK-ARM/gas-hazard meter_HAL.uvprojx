# Keil uVision project gas-hazard meter_HAL.uvprojx, settings and files
target gas-hazard meter_HAL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: gas-hazard meter_HAL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/SSD1315/Inc;../Drivers/DHT11/Inc;../Drivers/ESP32AT/Inc;../Drivers/GASS/Inc;../Interface/BUZZER/Inc;../Interface/GASS_MEASURE/Inc;../Interface/HUMITURE/Inc;../Interface/OLED/Inc;../Interface/ONENET/Inc;..\MID\FreeRTOS\include;..\MID\FreeRTOS\portable;..\MID\FreeRTOS\include;..\MID\FreeRTOS;..\App\App_Freertos
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c i2c.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/DHT11/Src
    ../Drivers/DHT11/Src/: dht11.c
  group Drivers/ESP32AT/Src
    ../Drivers/ESP32AT/Src/: esp32at.c
  group Drivers/GASS/Src
    ../Drivers/GASS/Src/: 21voc.c mq2.c
  group Drivers/SSD1315/Src
    ../Drivers/SSD1315/Src/: ssd1315.c font.c
  group Interface/BUZZER/Src
    ../Interface/BUZZER/Src/: buzzer.c
  group Interface/GASS_MEASURE/Src
    ../Interface/GASS_MEASURE/Src/: gass_measure.c
  group Interface/HUMITURE/Src
    ../Interface/HUMITURE/Src/: humiture.c
  group Interface/OLED/Src
    ../Interface/OLED/Src/: oled.c
  group Interface/ONENET/Src
    ../Interface/ONENET/Src/: onenet.c
  group MID/Freertos
    ../MID/FreeRTOS/portable/: heap_4.c port.c
    ../MID/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../MID/FreeRTOS/: FreeRTOSConfig.h
  group App
    ../App/App_Freertos/: app_freertos.c
software components: CMSIS:CORE 4.3.0
